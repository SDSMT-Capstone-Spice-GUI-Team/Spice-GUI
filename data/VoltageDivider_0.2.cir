SPICE Netlist:

* Circuit Netlist Generated by Circuit Design GUI

R1 N2 N3 1k
R2 N3 N1 1k
V1 N1 N2 DC 1u

* Labeled Nodes:
* Node 0 = N1
* Node 2 = N2
* Node 3 = N3

* Analysis Type
.op

.end
